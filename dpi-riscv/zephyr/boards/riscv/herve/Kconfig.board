## dpi-riscv/zephyr/boards/riscv/herve/Kconfig.board
```kconfig
# Herve RISC-V ISS board configuration

config BOARD_HERVE
	bool "Herve RISC-V ISS"
	depends on SOC_RISCV32_P
```
